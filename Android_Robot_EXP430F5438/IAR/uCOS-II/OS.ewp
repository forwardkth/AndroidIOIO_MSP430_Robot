# IAR project OS.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xldn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ; ..\BSP\; ..\BSP\MSP-EXP430F5438 HAL\; ..\BSP\F5xx_F6xx_Core_lib\; ..\..\..\..\..\uC-CPU\; ..\..\..\..\..\uC-CPU\MSP430X\IAR; ..\..\..\..\..\uC-LIB\; ..\..\..\..\..\uCOS-II\Source\; ..\..\..\..\..\uCOS-II\Ports\MSP430X\IAR\MSP430x5xx\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: DISABLE_WATCHDOG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: CC430F5133 CC430F5133
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group App
    ./: app.c app_cfg.h app_hooks.c cpu_cfg.h cstartup.s43 includes.h os_cfg.h
  group BSP
    ../BSP/: bsp.c bsp.h
  group BSP/F5xx_F6xx_Core_Lib
    ../BSP/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h hal_macros.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group BSP/MSP-EXP430F5438 HAL
    ../BSP/MSP-EXP430F5438 HAL/: cc2500.h hal_adc.h hal_board.c hal_board.h hal_buttons.c hal_buttons.h hal_lcd.c hal_lcd.h hal_lcd_fonts.h hal_MSP-EXP430F5438.h hal_rf.c hal_rf.h hal_usb.c hal_usb.h
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/MSP430X
    ../../../../../uC-CPU/MSP430X/IAR/: cpu.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-II/Port
    ../../../../../uCOS-II/Ports/MSP430X/IAR/MSP430x5xx/: os_cpu.h os_cpu_a.s43 os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
